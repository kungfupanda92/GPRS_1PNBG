# Keil uVision project GPRS_Module.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2132 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0xFFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: GPRS_Module +hex
  c flags: Optim=1
  c include: .\source
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT5: ROM 0x8000 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group User
    ./source/: gprs_com.c LPC213x_isr.c main.c read_para.c save_flash.c stringconvert.c variable.c m25lc512.c
  group Periph_Driver
    ./source/: delay.c gpio.c iap.c init_system.c retarget.c rtc.c timer.c uart0.c uart1.c wdt.c spi.c
  group Start up
    ./: Startup.s
